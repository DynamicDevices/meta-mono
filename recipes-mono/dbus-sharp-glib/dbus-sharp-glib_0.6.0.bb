require dbus-sharp-glib.inc

SRC_URI += "file://0001-configure-use-mcs.patch"

SRC_URI[sha256sum] = "d337d5a4dbaab2084972f85d175ba30ca87aa6baaa635288f3b37ca71f2d9047"
