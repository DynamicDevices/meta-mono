require dotnet.inc

DOTNET_RUNTIME_VERSION = "8.0.10"

SRC_FETCH_ID:aarch64 = "853490db-6fd3-4c17-ad8e-9dbb61261252/3d36d7d5b861bbb219aa1a66af6e6fd2"
SRC_SHA512SUM:aarch64 = "f42e1ba9a897f91c8d734b09a9bfc82428f0629b7cdd9375262158d9f282797c199558c37ae7f36947e57d8adc61af9490595c4e6bbd05217fd6d05133dded4d"

SRC_FETCH_ID:arm = "382e3bc7-f055-48b9-965b-89b070c15713/54b2af6b1ef970f852c29a850661728b"
SRC_SHA512SUM:arm = "ddcc229316475ba73cc46518ea263a97bd57fa7846a4fe76efb90f874311e8a7f5718ac6dcb8616835b4321af46f0e0265ae48b106e5adc9ba82cce88e804a4b"

SRC_FETCH_ID:x86-64 = "ca6cd525-677e-4d3a-b66c-11348a6f920a/ec395f498f89d0ca4d67d903892af82d"
SRC_SHA512SUM:x86-64 = "7aa03678228b174f51c4535f18348cdf7a5d35e243b1f8cb28a4a30e402e47567d06df63c8f6da4bdc3c7e898f54f4acc08d9952bfa49d3f220d0353253ac3e9"
