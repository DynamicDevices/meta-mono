require dotnet.inc

DOTNET_RUNTIME_VERSION = "6.0.36"

SRC_FETCH_ID:aarch64 = "63915342-f75e-45b9-87c6-26191463df72/60c45022a869da1ad03b8522b0c6a7bd"
SRC_SHA512SUM:aarch64 = "cb8454865ecb99ce557bd0a5741d3dc84657a45ea00f9b2a0f0593e94e4e661e898a5690df90cf0175bf5982973c19985a168998aaa975b7ac7a3bef2ecd05d2"

SRC_FETCH_ID:arm = "e1f1b444-2b24-4ba6-a1a2-f669f6710127/45371782a57b927e6dcccdb02b04d763"
SRC_SHA512SUM:arm = "c751881dd27ef098428e616b99a9c16e8bf82526484f76987dac1efcb5177534749c8f943f6d9daacc3a91bb086c9cb9c8d535c9881c0be3dc19c647065968fe"

SRC_FETCH_ID:x86-64 = "35b1b4d1-b8f4-4b5c-9ddf-e64a846ee50b/93cc198f1c48fe5c4853bd937226f570"
SRC_SHA512SUM:x86-64 = "04395f991ab50e4755ce1ae53e23592a7420b71b82160883bae3194dd1dfd5dcaed78743e4e0b4dd51ea43c49ec84b5643630707b3854f1471265dc98490d2f9"
