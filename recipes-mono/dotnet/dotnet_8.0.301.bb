require dotnet.inc

DOTNET_RUNTIME_VERSION = "8.0.6"

SRC_FETCH_ID:aarch64 = "cd9decc0-f3ef-46d6-b7d1-348b757781ad/9ad92a8f4b805feb3d017731e78eca15"
SRC_SHA512SUM:aarch64 = "cb904a625d5e4ef4db995225d6705b84201dc7d7d09a0b1669baccc86e05419472719025036dd78983b21850f7663d159ae41926364d1d3ca0eab62862f75d29"

SRC_FETCH_ID:arm = "033ecbe9-b763-43e6-ae77-386cc6896f17/991838457685c131961652535f07c46b"
SRC_SHA512SUM:arm = "9a44abe4ab6c6a8b8b8c599b140722098e4c710fb86d3ff387402ce98fc5bdf2e8271558b2de0822b5ef73c8781d5fae219d69411697b3cd59ccfc0283286a69"

SRC_FETCH_ID:x86-64 = "86497c4f-3dc8-4ee7-9f6a-9e0464059427/293d074c28bbfd9410f4db8e021fa290"
SRC_SHA512SUM:x86-64 = "6e2e1ad5fe3f00e6974ad3eac9c5b74cd09521f19e06eb9aff45a44d6c55e4a2c1cd489364735215d2ea53cec2a7d45892a5ede344a8421be9ad15872c3496a2"
