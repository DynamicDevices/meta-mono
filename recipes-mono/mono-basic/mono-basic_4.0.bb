require mono-basic-4.xx.inc

SRC_URI[md5sum] = "c0783a53234ba878a103fcbc2f10630d"
SRC_URI[sha256sum] = "1760936b2b4d780fb69ccf230280216836d28a2c49d08f483afe2c3192d8359d"
