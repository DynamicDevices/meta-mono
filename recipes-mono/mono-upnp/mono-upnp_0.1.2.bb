require mono-upnp.inc

SRC_REV = "b374ed41c566bc6ad50b3513218458b711e508db"
SRCBRANCH = "master"

SRC_URI += "file://0001-fixup-build.patch \
	    file://0002-configure-use-mcs.patch \
"
