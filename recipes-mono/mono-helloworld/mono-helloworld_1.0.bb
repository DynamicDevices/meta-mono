require mono-helloworld.inc

SRC_URI[md5sum] = "2604a27a7fc84721bb9ce914fa14116b"
SRC_URI[sha256sum] = "52489d18619db0a669826c8fa39fb64d350163b956ac6f4fcd8523a4f8db04b1"

