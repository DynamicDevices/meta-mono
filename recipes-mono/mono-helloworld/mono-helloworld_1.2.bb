require mono-helloworld.inc

SRC_URI[md5sum] = "79b0ba0044689789a54e3d55ec400fc0"
SRC_URI[sha256sum] = "56388435f29ce94007155acc39593c900b6d3248a7f281e83ed2101a6da455f0"

