require mono-xsp-3.x.inc

SRC_URI[sha256sum] = "290e302a03396c5cff7eb53dae008e9f79dd00aca15ad1e62865907220483baa"
