require mono-xsp.inc

SRC_URI[sha256sum] = "931127419156f58fdd89250ff5de3eda9b6743473be0682ee42df2c70e93eda3"

