require mono-xsp-3.x.inc

SRCREV= "e272a2c006211b6b03be2ef5bbb9e3f8fefd0768"
SRC_URI = "git://github.com/mono/xsp.git \
	  "

S = "${WORKDIR}/git"
