require nuget.inc

SRC_URI[sha256sum] = "2865714c6588ef0770b4a04bdd20dac59bcb56756d001c040664c9966f1b835a"
