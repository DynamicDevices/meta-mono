require nuget.inc

SRC_URI[sha256sum] = "0eabcc242d51d11a0e7ba07b7f1bc746b0e28d49c6c0fc03edf715d252b03e13"
