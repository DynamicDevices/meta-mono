require nuget.inc

SRC_URI[sha256sum] = "4c1de9b026e0c4ab087302ff75240885742c0faa62bd2554f913bbe1f6cb63a0"
