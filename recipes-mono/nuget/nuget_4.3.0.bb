require nuget.inc

SRC_URI[md5sum] = "c539a4adf5af1de0ebdae0d1fad5852b"
SRC_URI[sha256sum] = "386da77a8cf2b63d1260b7020feeedabfe3b65ab31d20e6a313a530865972f3a"
