require nuget.inc

SRC_URI[sha256sum] = "399ec24c26ed54d6887cde61994bb3d1cada7956c1b19ff880f06f060c039918"
