require taglib-sharp.inc

SRCREV = "bbdc79138815c81151a5d03fc2dec0cf53044186"
SRCBRANCH = "main"

SRC_URI += "file://0001-configure-use-mcs.patch"
