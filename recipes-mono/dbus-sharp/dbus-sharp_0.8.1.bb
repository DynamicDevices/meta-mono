require dbus-sharp.inc

SRC_URI += "file://0001-configure-use-mcs.patch"

SRC_URI[md5sum] = "872ebacc5c9446033591f6dd2a781e72"
SRC_URI[sha256sum] = "531011702c544fd8861751668b95ade8cf1aa2254838c934a02c3b4367b92b63"

