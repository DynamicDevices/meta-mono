require mono-6.xx.inc
require mono-mit-bsd-6xx.inc
require mono-native-6.xx-base.inc
require mono-${PV}.inc

SRC_URI += "file://0001-patch-XplatUIX11-cursor.diff"

