require mono-git.inc
require ${PN}-base.inc
