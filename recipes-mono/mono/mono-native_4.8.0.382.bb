require mono-4.xx.inc
require mono-mit.inc
require ${PN}-base.inc
require mono-${PV}.inc
