require mono-5.xx.inc
require mono-mit-bsd.inc
require mono-native-5.xx-base.inc
require mono-${PV}.inc

DEPENDS += " cmake-native"
