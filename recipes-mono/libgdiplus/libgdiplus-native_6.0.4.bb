require libgdiplus-common.inc
require libgdiplus-native.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=e0a7dacaa67d7e24a32074fba736dc59"

BRANCH = "release/6.0"
SRCREV = "c5b9035d14146e054f2636f2e70dd3577bdaa397"
