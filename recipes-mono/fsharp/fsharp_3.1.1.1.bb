require fsharp.inc

inherit pkgconfig

SRC_URI[md5sum] = "2900b258f57db34ca51d0caba58c9cd3"
SRC_URI[sha256sum] = "ad3f53e835d18a0c53a12101c118619a1cb8e4f6c216001572790e9509679bcf"

