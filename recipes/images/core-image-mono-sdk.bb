require recipes-sato/images/core-image-sato-sdk.bb
require core-image-mono.inc
IMAGE_INSTALL += "mono-dev"

